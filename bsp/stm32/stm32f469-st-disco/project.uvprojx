# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F469xx, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND,STM32F4
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;board\ports\touch;.;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;packages\LVGL-latest\src;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\extra;packages\LVGL-latest\src\font;packages\LVGL-latest\src\gpu;packages\LVGL-latest\src\hal;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\widgets;packages\LVGL-latest\src\extra\layouts;packages\LVGL-latest\src\extra\libs;packages\LVGL-latest\src\extra\others;packages\LVGL-latest\src\extra\themes;packages\LVGL-latest\src\extra\widgets;packages\LVGL-latest\src\extra\layouts\flex;packages\LVGL-latest\src\extra\layouts\grid;packages\LVGL-latest\src\extra\libs\bmp;packages\LVGL-latest\src\extra\libs\freetype;packages\LVGL-latest\src\extra\libs\fsdrv;packages\LVGL-latest\src\extra\libs\gif;packages\LVGL-latest\src\extra\libs\png;packages\LVGL-latest\src\extra\libs\qrcode;packages\LVGL-latest\src\extra\libs\rlottie;packages\LVGL-latest\src\extra\libs\sjpg;packages\LVGL-latest\src\extra\others\snapshot;packages\LVGL-latest\src\extra\themes\basic;packages\LVGL-latest\src\extra\themes\default;packages\LVGL-latest\src\extra\themes\mono;packages\LVGL-latest\src\extra\widgets\animimg;packages\LVGL-latest\src\extra\widgets\calendar;packages\LVGL-latest\src\extra\widgets\chart;packages\LVGL-latest\src\extra\widgets\colorwheel;packages\LVGL-latest\src\extra\widgets\imgbtn;packages\LVGL-latest\src\extra\widgets\keyboard;packages\LVGL-latest\src\extra\widgets\led;packages\LVGL-latest\src\extra\widgets\list;packages\LVGL-latest\src\extra\widgets\meter;packages\LVGL-latest\src\extra\widgets\msgbox;packages\LVGL-latest\src\extra\widgets\span;packages\LVGL-latest\src\extra\widgets\spinbox;packages\LVGL-latest\src\extra\widgets\spinner;packages\LVGL-latest\src\extra\widgets\tabview;packages\LVGL-latest\src\extra\widgets\tileview;packages\LVGL-latest\src\extra\widgets\win;packages\LVGL-latest\src\gpu\sdl;packages\LVGL-latest\rt-thread;board\ports\lvgl;..\..\..\components\libc\posix\src;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: lcd_init.c main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c ringbuffer.c completion.c pipe.c waitqueue.c workqueue.c ringblk_buf.c
  group Drivers
    board/ports/: drv_otm8009a.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f469xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_lcd_mipi.c drv_sdram.c drv_soft_i2c.c drv_usart.c drv_common.c
    board/ports/touch/: drv_touch.c drv_touch_ft.c
  group Filesystem
    ../../../components/dfs/src/: dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ff.c dfs_elm.c ffunicode.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: kservice.c scheduler.c clock.c ipc.c components.c thread.c device.c memheap.c irq.c mempool.c timer.c object.c idle.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c mem_std.c libc_syms.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_hal_nor.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    packages/LVGL-latest/src/font/: lv_font_simsun_16_cjk.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_16.c lv_font_unscii_16.c lv_font_montserrat_12_subpx.c lv_font_montserrat_46.c lv_font_montserrat_34.c lv_font_montserrat_12.c lv_font_montserrat_44.c lv_font_montserrat_22.c lv_font_montserrat_28.c lv_font_montserrat_36.c lv_font.c lv_font_montserrat_24.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_30.c lv_font_montserrat_10.c lv_font_montserrat_20.c lv_font_montserrat_18.c lv_font_unscii_8.c lv_font_montserrat_42.c lv_font_montserrat_26.c lv_font_montserrat_14.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_28_compressed.c lv_font_montserrat_48.c lv_font_montserrat_32.c
    packages/LVGL-latest/src/core/: lv_refr.c lv_obj.c lv_theme.c lv_obj_tree.c lv_indev_scroll.c lv_obj_pos.c lv_indev.c lv_obj_draw.c lv_event.c lv_obj_scroll.c lv_disp.c lv_obj_style.c lv_group.c lv_obj_style_gen.c lv_obj_class.c
    packages/LVGL-latest/src/widgets/: lv_arc.c lv_roller.c lv_bar.c lv_textarea.c lv_img.c lv_slider.c lv_canvas.c lv_label.c lv_switch.c lv_checkbox.c lv_objx_templ.c lv_dropdown.c lv_btn.c lv_table.c lv_line.c lv_btnmatrix.c
    packages/LVGL-latest/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/extra/widgets/led/: lv_led.c
    packages/LVGL-latest/src/misc/: lv_area.c lv_tlsf.c lv_bidi.c lv_math.c lv_color.c lv_anim_timeline.c lv_log.c lv_txt.c lv_txt_ap.c lv_fs.c lv_mem.c lv_gc.c lv_timer.c lv_async.c lv_ll.c lv_style.c lv_style_gen.c lv_utils.c lv_templ.c lv_printf.c lv_anim.c
    packages/LVGL-latest/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-latest/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_posix.c lv_fs_stdio.c lv_fs_fatfs.c
    packages/LVGL-latest/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-latest/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/gpu/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c lv_gpu_sdl.c
    packages/LVGL-latest/src/gpu/sdl/: lv_gpu_sdl_lru.c lv_gpu_sdl_draw_arc.c lv_gpu_sdl_mask.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_utils.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_draw_label.c
    packages/LVGL-latest/src/draw/: lv_draw_img.c lv_draw_blend.c lv_draw_triangle.c lv_draw_label.c lv_draw_arc.c lv_draw_mask.c lv_img_decoder.c lv_img_buf.c lv_draw_line.c lv_img_cache.c lv_draw_rect.c
    packages/LVGL-latest/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-latest/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-latest/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-latest/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-latest/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-latest/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-latest/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-latest/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/LVGL-latest/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-latest/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-latest/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/extra/widgets/list/: lv_list.c
    packages/LVGL-latest/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/extra/widgets/span/: lv_span.c
    packages/LVGL-latest/src/extra/widgets/win/: lv_win.c
    packages/LVGL-latest/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/extra/: lv_extra.c
    packages/LVGL-latest/src/extra/widgets/keyboard/: lv_keyboard.c
  group LVGL-port
    packages/LVGL-latest/rt-thread/: lv_rt_thread_port.c
    board/ports/lvgl/: lv_port_disp.c lv_demo.c lv_port_indev.c
  group POSIX
    ../../../components/libc/posix/src/: delay.c libc.c select.c unistd.c poll.c
