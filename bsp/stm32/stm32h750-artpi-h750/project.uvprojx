# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32H750xx, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND,__MPU_PRESENT=1
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Core\Inc;board\port;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\STM32H7xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: mpu_inf.c main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: pipe.c dataqueue.c completion.c ringblk_buf.c waitqueue.c ringbuffer.c workqueue.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c idle.c object.c scheduler.c thread.c mem.c timer.c device.c ipc.c kservice.c irq.c clock.c mempool.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
